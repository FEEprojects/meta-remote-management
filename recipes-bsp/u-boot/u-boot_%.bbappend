FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = " file://0001-do-not-start-autoboot-at-keypressing.patch "
